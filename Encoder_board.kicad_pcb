# Repository KeioRoboticsAssociation/NHK2026_Encoderboard

## KiCad design Encoder_board.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C7, C9, C10, C11, C12, C14, C15, C16, C17, C18: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 35V 220u; CP_Radial_D8.0mm_P3.50mm
C8: 16V 220u; CP_Radial_D6.3mm_P2.50mm
C13: 16V 100u; CP_Radial_D6.3mm_P2.50mm
D1: RB168MM100TR; SOD123
D2, D3, D5, D8: 1N4148; SOD123
D4, D6, D7, D9: LED; LED_D3.0mm
F1: Polyfuse_MF-RX040; C_Disc_D7.5mm_W2.5mm_P5.00mm
J1: Conn_01x05_Socket_RS485; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J2: CAN_OUT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: Conn_01x05_Socket_Encoder4; Pocket_Header_ver
J4: Conn_01x05_Socket_Encoder1; Pocket_Header_ver
J5: Conn_01x05_Socket_Encoder2; Pocket_Header_ver
J6: Conn_01x05_Socket_Encoder5; Pocket_Header_ver
J7: ST-Link_pinsocket; PinSocket_2x06_P2.54mm_Vertical
J8: Conn_01x05_Socket_Encoder3; Pocket_Header_ver
R1, R2, R7: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R22, R23, R24, R25: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R11, R12, R15, R16, R17, R18, R20, R21: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R19: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Boot; SW_PUSH_6mm_H4.3mm
SW2: SW_Reset; SW_PUSH_6mm_H4.3mm
SW3: SW_DIP_x02_CANnum; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W7.62mm_P2.54mm_LowProfile
SW4: SW_User; SW_PUSH_6mm_H4.3mm
U1: XT60_M; AMASS_XT60-M_1x02_P7.20mm_Vertical
U2, U3: UTRS485G-S08-R; SOP-8
U4: MCP2562-E-P; DIP-8_W7.62mm
U5: BA05CC0FP; TO-252-2
U6: BA033CC0FP; TO-252-2
U7: STM32G431KBTx; LQFP-32_7x7mm_P0.8mm

Connections:
+3V3: C1.1, C12.1, C13.1, C16.1, C18.1, D5.2 (A), D8.1 (K), J7.1, R14.1, R22.1, R23.1, R24.1, R25.1, U4.5 (Vio), U6.3 (OUT), U7.1 (VDD), U7.15 (VDDA), U7.17 (VDD)
+5V: C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C11.1, C14.1, C15.1, C17.1, D2.2 (A), D3.1 (K), D5.1 (K), J3.4, J4.4, J5.4, J6.4, J7.8, J8.4, R3.2, R5.2, R9.1, R10.1, R11.1, R12.1, R13.1, R15.1, R16.1, R17.1, R18.1, R20.1, R21.1, U2.2 (~RE), U2.3 (DE), U2.8 (VCC), U3.8 (VCC), U4.3 (VDD), U5.3 (OUT), U6.1 (IN)
+12V: F1.1, R8.1, U1.2
CAN_RD: U4.4 (RXD), U7.21 (PA11)
CAN_TD: U4.1 (TXD), U7.22 (PA12)
En1_A_Tim1_CH1: J4.3, R10.2, U7.18 (PA8)
En1_B_Tim1_CH2: J4.5, R12.2, U7.19 (PA9)
En2_A_Tim2_CH1: J5.3, R15.2, U7.5 (PA0)
En2_B_Tim2_CH2: J5.5, R17.2, U7.6 (PA1)
En3_A_Tim3_CH1: J8.3, R20.2, U7.11 (PA6)
En3_B_Tim3_CH2: J8.5, R21.2, U7.9 (PA4)
En4_A_Tim4_CH1: J3.3, R9.2, U7.29 (PB6)
En4_B_Tim4_CH2: J3.5, R11.2, U7.30 (PB7)
En5_A_Tim8_CH1: J6.3, R16.2, U7.25 (PA15)
En5_B_Tim8_CH2: J6.5, R18.2, SW1.1, U7.31 (PB8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D3.2 (A), D4.1 (K), D6.1 (K), D7.1 (K), D8.2 (A), D9.1 (K), J1.1, J3.1, J4.1, J5.1, J6.1, J7.5, J7.12, J8.1, R4.1, R6.1, SW1.2, SW2.2, SW3.3, SW3.4, SW4.2, U1.1, U2.5 (GND), U3.2 (~RE), U3.3 (DE), U3.5 (GND), U4.2 (VSS), U4.8 (STBY), U5.2 (GND), U6.2 (GND), U7.14 (VSSA), U7.16 (VSS), U7.32 (VSS)
MCO_IN: J7.10, U7.2 (PF0)
unnamed: D1.2 (A), F1.2
unnamed: C5.1, C6.1, D1.1 (K), D2.1 (K), U5.1 (IN)
unnamed: D4.2 (A), R8.2
unnamed: D6.2 (A), R13.2
unnamed: D7.2 (A), R14.2
unnamed: D9.2 (A), R19.2
unnamed: J1.2, R2.1, R4.2, U2.6 (A)
unnamed: J1.3, R2.2, R3.1, U2.7 (B)
unnamed: J1.4, R1.1, R6.2, U3.6 (A)
unnamed: J1.5, R1.2, R5.1, U3.7 (B)
unnamed: J2.1, R7.1, U4.7 (CANH)
unnamed: J2.2, R7.2, U4.6 (CANL)
RESET: J7.9, R22.2, SW2.1, U7.4 (PG10)
RS485_RX: J7.6, U3.1 (RO), U7.8 (PA3)
RS485_TX: J7.4, U2.4 (DI), U7.7 (PA2)
SWCLK: J7.3, U7.24 (PA14)
SWDIO: J7.7, U7.23 (PA13)
User_LED: R19.1, U7.13 (PB0)
User_button: R25.2, SW4.1, U7.28 (PB5)
board_num1: R23.2, SW3.1, U7.12 (PA7)
board_num2: R24.2, SW3.2, U7.10 (PA5)

Notes on the sheet:
GND
Bootを3V3接続から GND接続に変更しました
STのチップマイコンを使用する場合は ST-Linkコネクタを載せましょう ここにピンソケットをつけて線でST-Linkのボードにつなぐ 済
ENCODER
発熱敵にBA05CC0FPで耐えることが 判明したので変更しましょう 済
エンコーダのA相B相はプルアップしてください 抵抗値、電源電圧は合っています 済
VSSも全てに接続しましょう
VDDは全てに接続しましょう
TX_B
FDCAN
RX_B
5ピンのコネクタに変更して GNDを追加してください GNDは1ピンとしてください 済
RS485
TX_A
G431 KBT6
RX_A
3V3に統一しましょう 済

Board: 2 copper layers, 70.0 x 70.0 mm, 72 parts (31 on the bottom side), 38 nets.

## Commit log

2025-09-27 first
2025-09-30 回路図を書き進めた（未完）
2025-09-30 回路図を一応完成。ミスがないか、動作するか確認する
2025-10-05 少し修正
2025-10-05 コミット自体のテスト
2025-10-08 回路図完成
2025-10-10 部品を配置
2025-10-12 配線終了。あとはシルク
2025-10-12 塗りつぶしとビアうち終了
2025-10-12 とりあえず完成
2025-10-12 ねじ穴の位置を修正
2025-10-12 基板名を追加
2025-10-13 コメントをPCBエディタに追加
2025-10-14 修正完了
2025-10-15 シルクを一部修正
2025-10-19 基板外形を修正
